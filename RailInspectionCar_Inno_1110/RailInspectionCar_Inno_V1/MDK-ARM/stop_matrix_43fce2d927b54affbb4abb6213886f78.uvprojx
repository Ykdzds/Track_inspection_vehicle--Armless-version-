# Keil uVision project stop_matrix_43fce2d927b54affbb4abb6213886f78.uvprojx, settings and files
target RailInspectionCar_V1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80DFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stop_axis_3_hold_1_readonly_0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,APP_SERVO_QUERY_MODE=3,APP_SERVO_CONTROL_AXIS=3,APP_SERVO_STARTUP_HOLD_ENABLED=1,APP_SERVO_READONLY_TEST=0,APP_CAN_CONTROL_ENABLED=1
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../APP;../APP/HMI;../BSP/LED;../BSP/BEEP;../BSP/KEY;../BSP/RS485;../BSP/SPI_LCD;../BSP/SERVO_PULSE;../BSP/DEBUG_UART;../BSP/SYSTEM;../BSP/NRF24L01;../BSP/CAN;../BSP/HMI_UART;../Protocol;../Protocol/CAN;../Protocol/HMI;../Device
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP/LED
    ../BSP/LED/: led.c
  group BSP/BEEP
    ../BSP/BEEP/: beep.c
  group BSP/KEY
    ../BSP/KEY/: key.c
  group BSP/SPI_LCD
    ../BSP/SPI_LCD/: lcd_core.c lcd_font.c lcd_port.c bsp_lcd.c
  group BSP/DEBUG_UART
    ../BSP/DEBUG_UART/: debug_uart.c
  group BSP/SYSTEM
    ../BSP/SYSTEM/: bsp_system.c
  group BSP/RS485
    ../BSP/RS485/: bsp_rs485.c
  group BSP/SERVO_PULSE
    ../BSP/SERVO_PULSE/: servo_pulse.c
  group BSP/NRF24L01
    ../BSP/NRF24L01/: NRF24L01.c
  group BSP/HMI_UART
    ../BSP/HMI_UART/: bsp_hmi_uart.c
  group BSP/CAN
    ../BSP/CAN/: bsp_can.c bsp_can_identity.c
  group Protocol/Modbus
    ../Protocol/: modbus_rtu.c
  group Protocol/HMI
    ../Protocol/HMI/: hmi_modbus_slave.c
  group Protocol/CAN
    ../Protocol/CAN/: can_protocol.c can_link.c can_identity.c can_upper.c can_arm.c
  group Device/AIMtor Servo
    ../Device/: aimtor_servo.c
  group APP/System
    ../APP/: app_config.c app_rtos_create.c app_rtos_task.c app_health.c app_boot_identity.c
  group APP/Motion
    ../APP/: app_remote_servo.c app_remote_servo_sync.c motion_control.c
  group APP/Position
    ../APP/: app_position_monitor.c
  group APP/NRF Remote
    ../APP/: app_nrf_remote.c nrf_remote_protocol.c nrf_status_telemetry.c
  group APP/HMI
    ../APP/HMI/: app_hmi.c app_hmi_control.c app_hmi_snapshot.c app_hmi_state.c app_control_arbiter.c
    ../APP/: app_system_snapshot.c
  group APP/CAN
    ../APP/: app_can.c app_can_config.c app_can_control.c app_can_status.c
  group APP/CLI
    ../APP/: app_debug_cli.c app_cli_servo_session.c servo_debug_control.c
  group APP/Display
    ../APP/: app_lcd_show.c
software components: CMSIS:CORE 5.5.0
